## src/examples/fake_linedetect/Kconfig
```kconfig
menuconfig EXAMPLES_FAKE_LINEDETECT
	bool "fake_linedetect"
	default n
	---help---
		Enable support for fake_linedetect
```
